# Keil uVision project usbd_vcp.uvproj, settings and files
target USBD_VCP-STM32072B-EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32072B_EVAL,USE_STDPERIPH_DRIVER,STM32F072
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\app;..\usb_cdc_hal\inc;..\..\..\Libraries\freeRtos\Source\include;..\..\Virtual_COM_Port;..\..\..\Libraries\freeRtos\Source\portable\RVDS\ARM_CM0;..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000100 size 0x3f00
  group App
    ../app/: stm32_it.c stm32_it.h stm32f0xx_conf.h app.c FreeRTOSConfig.h Board.c Board.h AppTask_BroadcomBle.c AppTask_BroadcomBle.h AppTask_Start.c AppTask_Start.h AppTask_Uart1.c AppTask_Uart1.h AppTask_Uart2.c AppTask_Uart2.h AppTask_Uart3.c AppTask_Uart3.h Broadcom_Ble.c Broadcom_Ble.h CRC.c CRC.h Old_Protocol.c Old_Protocol.h Protocol_Parser.c Protocol_Paser.h Ring_Buf.c Ring_Buf.h serialManager.c serialManager.h Read_ModuleID.c Read_ModuleID.h
  group USB_Class
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s system_stm32f0xx.c
  group STM32F072_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_adc.c
  group usb_cdc_hal
    ../usb_cdc_hal/inc/: hw_config.h usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
    ../usb_cdc_hal/src/: hw_config.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
  group FreeRTOS
    ../../../Libraries/freeRtos/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../Libraries/freeRtos/Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../../../Libraries/freeRtos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Libraries/freeRtos/Source/portable/MemMang/: heap_2.c
