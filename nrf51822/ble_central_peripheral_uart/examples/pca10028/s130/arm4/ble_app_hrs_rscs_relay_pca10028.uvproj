# Keil uVision project ble_app_hrs_rscs_relay_pca10028.uvproj, settings and files
target nrf51422_xxaa_s130 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51422_xxaa_s130 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF_LOG_USES_RTT=1 BOARD_PCA10028 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\bsp;..\..\..\..\components\device;..\..\..\..\components\toolchain;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\components\ble\common;..\..\..\..\components\ble\peer_manager;..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\config;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\components\libraries\fds;..\..\..\..\components\libraries\fstorage;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\trace;..\..\..\..\components\libraries\uart;..\..\..\..\components\libraries\util;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\softdevice\s130\headers;..\..\..\user;..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\components\ble\ble_services\ble_nus
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Board Support
    ../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../components/ble/peer_manager/: gatt_cache_manager.c gattc_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../components/ble/ble_services/ble_nus_c/: ble_nus_c.c ble_nus_c.h
    ../../../../components/ble/ble_services/ble_nus/: ble_nus.c ble_nus.h
  group nRF_Drivers
    ../../../../components/libraries/uart/: app_uart.c
    ../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c sdk_mapped_flags.c
    ../../../../components/libraries/timer/: app_timer.c
    ../../../../components/libraries/trace/: app_trace.c
    ../../../../components/libraries/fds/: fds.c
    ../../../../components/libraries/fstorage/: fstorage.c
    ../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group ble_uart
    ../../../user/: ble_uart_central_profile.c ble_uart_central_profile.h ble_uart_peripheral_profile.c ble_uart_peripheral_profile.h
target flash_s130_nrf51_1.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF_LOG_USES_RTT=1 NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF_LOG_USES_RTT=1 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
