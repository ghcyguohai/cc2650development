# Keil uVision project ble_app_uart_c_s130_pca10028.uvproj, settings and files
target nrf51422_xxac_s130 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT S130 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\ble_app_uart_c_s130_pca10028;..\..\..\config;..\..\..\bsp;..\..\..\..\components\device;..\..\..\..\components\toolchain;..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\components\ble\common;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\drivers_nrf\config;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\fifo;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\trace;..\..\..\..\components\libraries\uart;..\..\..\..\components\libraries\util;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\softdevice\s130\headers;..\..\..\user;..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\drivers_nrf\pstorage\config;..\..\..\..\components\drivers_nrf\pstorage
  asm define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Board Support
    ../../../bsp/: bsp.c
  group Device
    ../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../components/ble/ble_services/ble_nus_c/: ble_nus_c.c
    ../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/libraries/timer/: app_timer.c
    ../../../../components/libraries/trace/: app_trace.c
    ../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group User
    ../../../user/: ble_uart_central_profile.c ble_uart_central_profile.h ble_uart_peripheral_profile.c ble_uart_peripheral_profile.h
target flash_s130_nrf51_1.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config\ble_app_uart_c_s130_pca10028;..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain
  asm define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
