# Keil uVision project ble_app_uart_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_s110 +hex
  AfterMake: D:\MDK\ARM\ARMCC\bin\fromelf.exe --bin -o  ./_build/@L.bin  ./_build/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\ble_app_uart;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\ble\device_manager\config;..\arm5_no_packs;..\..\s110;..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c at.c at.h Ble_Passthrough_Handle.c Ble_Passthrough_Handle.h ble_configservice.c ble_configservice.h Ble_FirmwareInfo.c Ble_FirmwareInfo.h
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu.h
    ../../../../../../components/libraries/bootloader_dfu/: dfu_app_handler.c dfu_app_handler.h bootloader_util.c bootloader_util.h
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c pstorage.h
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/swi/: nrf_drv_swi.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s110_nrf51_8.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0, Device:Startup 8.9.0
